DESCRIPTION = "chronos initram"

include recipes-core/initramfs/include/chronos.inc

PACKAGE_INSTALL = " \
        initrd-boot \
        "
