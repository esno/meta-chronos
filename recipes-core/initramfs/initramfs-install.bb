DESCRIPTION = "chronos installer initram"

include recipes-core/initramfs/include/chronos.inc

PACKAGE_INSTALL = " \
        chronos-install \
        "
