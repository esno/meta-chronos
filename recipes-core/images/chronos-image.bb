SUMMARY = "chronos generic image"
LICENSE = "MIT"

inherit chronos-image
